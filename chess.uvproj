# Keil uVision project chess.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: chess +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./src/: main.c uart.c helpers.c shift_registers.c bitboard.c interrupts.c move_gen.c tasks.c detection.c lcd.c
    ./: STARTUP.A51
